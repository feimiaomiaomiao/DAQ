# Keil uVision project RTOS_DAQ_V2.2.0.uvprojx, settings and files
target DAQ_RTOS (5060960::V5.06 update 7 (build 960)::.\version5.06)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_DAQ_V2.2.0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Drivers\Libraries\CMSIS;..\Drivers\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Drivers\System\inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\Drivers\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Drivers/Libraries/CMSIS/: core_cm3.c
    ../Drivers/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c FreeRTOSConfig.h freeRTOS_adc.c
    ../Drivers/Libraries/CMSIS/: system_stm32f10x.c
  group System
    ../Drivers/System/src/: delay.c usart.c sys.c
  group Hardware
    ../Drivers/Hardware/src/: ADC.C display.c EXTI.C Key.c led.c OLED.c OLED_Data.c timer.c
  group STM32F10x_StdPeriph_Driver
    ../Drivers/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c
  group FreeRTOS_CORE
    ../Middlewares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group Readme
    ../User/: Readme.txt
